options:
  parameters:
    author: F1ATB - BUHART
    description: TX NBFM Audio SDR = SA818
    generate_options: no_gui
    id: sa818_tx_nbfm_v3
    output_language: python
    run_options: run
    title: NBFM Transmitter V3 - F1ATB - OCT 2021
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '16000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: hw:0,0
    samp_rate: samp_rate
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '32767'
  states: {}
- name: blocks_udp_source_0
  id: blocks_udp_source
  parameters:
    eof: 'True'
    ipaddr: 127.0.0.1
    maxoutbuf: '2048'
    port: '9005'
    psize: '256'
    type: short
    vlen: '1'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '10'
    interp: '16'
    taps: ''
    type: fff
  states: {}

connections:
- [blocks_short_to_float_0, '0', rational_resampler_xxx_0, '0']
- [blocks_udp_source_0, '0', blocks_short_to_float_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']

metadata:
  file_format: 1
