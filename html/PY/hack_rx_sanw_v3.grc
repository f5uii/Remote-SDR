options:
  parameters:
    author: F1ATB - BUHART
    description: RX for HACK RF or RTL-SDR
    generate_options: no_gui
    id: hack_rx_sanw_v3
    output_language: python
    run_options: run
    title: SSB AM NBFN WBFM  Receiver V3- F1ATB - OCT 2021
  states: {}

blocks:
- name: F_Fine
  id: variable
  parameters:
    value: '0'
  states: {}
- name: FrRX
  id: variable
  parameters:
    value: '7000000'
  states: {}
- name: Gain_BB
  id: variable
  parameters:
    value: '20'
  states: {}
- name: Gain_IF
  id: variable
  parameters:
    value: '20'
  states: {}
- name: Gain_RF
  id: variable
  parameters:
    value: '0'
  states: {}
- name: LSB_USB
  id: variable
  parameters:
    value: min(1,Modulation)
  states: {}
- name: Largeur_filtre_AM
  id: variable
  parameters:
    value: '7500'
  states: {}
- name: Largeur_filtre_NBFM
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: Largeur_filtre_SSB
  id: variable
  parameters:
    value: '3800'
  states: {}
- name: Largeur_filtre_WBFM
  id: variable
  parameters:
    value: '150000'
  states: {}
- name: ModulSelect
  id: variable
  parameters:
    value: max(0,Modulation -1)
  states: {}
- name: Modulation
  id: variable
  parameters:
    value: '0'
  states: {}
- name: Squelch
  id: variable
  parameters:
    value: '-80'
  states: {}
- name: decim_LP
  id: variable
  parameters:
    value: '16'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2400e3
  states: {}
- name: xlate_filter_taps_AM
  id: variable
  parameters:
    value: firdes.low_pass(1, samp_rate, Largeur_filtre_AM/2, 1500)
  states: {}
- name: xlate_filter_taps_NBFM
  id: variable
  parameters:
    value: firdes.low_pass(1, samp_rate, Largeur_filtre_NBFM/2, 2000)
  states: {}
- name: xlate_filter_taps_SSB
  id: variable
  parameters:
    value: firdes.low_pass(1, samp_rate, Largeur_filtre_SSB/2, 760)
  states: {}
- name: xlate_filter_taps_WBFM
  id: variable
  parameters:
    value: firdes.low_pass(1, samp_rate, Largeur_filtre_WBFM/2, 25000)
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '0.1'
    decay_rate: '0.01'
    gain: '1.0'
    max_gain: '100'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '20000'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: int(samp_rate/240)
    max_dev: 5e3
    quad_rate: int(samp_rate/60)
    tau: '75e-6'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: Largeur_filtre_SSB/2+100
    offset: '0'
    phase: '0'
    samp_rate: samp_rate/240
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: Squelch
  states: {}
- name: analog_simple_squelch_cc_0_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: Squelch
  states: {}
- name: analog_simple_squelch_cc_0_1
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: Squelch
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '16'
    quad_rate: samp_rate/15
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '16000'
  states: {}
- name: blocks_float_to_short_1
  id: blocks_float_to_short
  parameters:
    scale: '100'
    vlen: '2048'
  states: {}
- name: blocks_keep_m_in_n_0
  id: blocks_keep_m_in_n
  parameters:
    m: int(2048*decim_LP)
    n: '409600'
    offset: '0'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1-2*LSB_USB
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '4'
    output_index: ModulSelect
    type: complex
  states: {}
- name: blocks_selector_1
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: ModulSelect
    num_inputs: '4'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_udp_sink_0
  id: blocks_udp_sink
  parameters:
    eof: 'True'
    ipaddr: 127.0.0.1
    port: '9001'
    psize: '1000'
    type: short
    vlen: '1'
  states: {}
- name: blocks_udp_sink_1
  id: blocks_udp_sink
  parameters:
    eof: 'True'
    ipaddr: 127.0.0.1
    port: '9002'
    psize: '4096'
    type: short
    vlen: '2048'
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '1024'
    long_form: 'True'
    type: cc
  states: {}
- name: device
  id: parameter
  parameters:
    type: str
    value: ''
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: F_Fine-Largeur_filtre_SSB/2+LSB_USB*Largeur_filtre_SSB-100+LSB_USB*200
    decim: '240'
    samp_rate: samp_rate
    taps: xlate_filter_taps_SSB
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: F_Fine
    decim: '60'
    samp_rate: samp_rate
    taps: xlate_filter_taps_NBFM
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: F_Fine
    decim: '240'
    samp_rate: samp_rate
    taps: xlate_filter_taps_AM
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_2
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: F_Fine
    decim: '15'
    samp_rate: samp_rate
    taps: xlate_filter_taps_WBFM
    type: ccc
  states: {}
- name: logpwrfft_x_0
  id: logpwrfft_x
  parameters:
    average: 'False'
    avg_alpha: '1.0'
    fft_size: '2048'
    frame_rate: samp_rate/200/2048
    ref_scale: '0.00001'
    sample_rate: samp_rate/200
    type: complex
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '5200'
    gain: '1'
    interp: '1'
    samp_rate: decim_LP*samp_rate/200
    type: interp_fir_filter_ccf
    width: '1200'
    win: firdes.WIN_HAMMING
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: decim_LP
    type: complex
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: device
    bb_gain0: Gain_BB
    dc_offset_mode0: '2'
    freq0: FrRX
    gain0: Gain_RF
    gain_mode0: 'False'
    if_gain0: Gain_IF
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: localhost
    port: '9003'
  states: {}

connections:
- [analog_agc2_xx_0, '0', blocks_complex_to_float_0, '0']
- [analog_agc_xx_0, '0', analog_simple_squelch_cc_0_0, '0']
- [analog_nbfm_rx_0, '0', blocks_selector_1, '2']
- [analog_sig_source_x_0, '0', blocks_complex_to_float_0_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_nbfm_rx_0, '0']
- [analog_simple_squelch_cc_0_0, '0', blocks_complex_to_mag_0, '0']
- [analog_simple_squelch_cc_0_1, '0', analog_wfm_rcv_0, '0']
- [analog_wfm_rcv_0, '0', blocks_selector_1, '3']
- [blocks_add_xx_0, '0', blocks_selector_1, '0']
- [blocks_complex_to_float_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_float_0, '1', blocks_multiply_xx_0_0, '0']
- [blocks_complex_to_float_0_0, '0', blocks_multiply_xx_0, '0']
- [blocks_complex_to_float_0_0, '1', blocks_multiply_xx_0_0, '1']
- [blocks_complex_to_mag_0, '0', blocks_selector_1, '1']
- [blocks_float_to_short_0, '0', blocks_udp_sink_0, '0']
- [blocks_float_to_short_1, '0', blocks_udp_sink_1, '0']
- [blocks_keep_m_in_n_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_add_xx_0, '1']
- [blocks_selector_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_selector_0, '1', freq_xlating_fir_filter_xxx_0_1, '0']
- [blocks_selector_0, '2', freq_xlating_fir_filter_xxx_0_0, '0']
- [blocks_selector_0, '3', freq_xlating_fir_filter_xxx_0_2, '0']
- [blocks_selector_1, '0', blocks_float_to_short_0, '0']
- [dc_blocker_xx_0, '0', blocks_keep_m_in_n_0, '0']
- [dc_blocker_xx_0, '0', blocks_selector_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_agc2_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', analog_simple_squelch_cc_0, '0']
- [freq_xlating_fir_filter_xxx_0_1, '0', analog_agc_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0_2, '0', analog_simple_squelch_cc_0_1, '0']
- [logpwrfft_x_0, '0', blocks_float_to_short_1, '0']
- [low_pass_filter_0, '0', mmse_resampler_xx_0, '0']
- [mmse_resampler_xx_0, '0', logpwrfft_x_0, '0']
- [osmosdr_source_0, '0', dc_blocker_xx_0, '0']

metadata:
  file_format: 1
