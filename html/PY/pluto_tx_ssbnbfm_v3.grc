options:
  parameters:
    author: F1ATB - BUHART
    description: TX SSB NBFM Adalm Pluto SDR
    generate_options: no_gui
    id: pluto_tx_ssbnbfm_v3
    output_language: python
    run_options: run
    title: SSB NBFM Transmitter V3 - F1ATB - OCT 2021
  states: {}

blocks:
- name: Fr_TX
  id: variable
  parameters:
    value: '145200000'
  states: {}
- name: GainBB_TX
  id: variable
  parameters:
    value: '0'
  states: {}
- name: GainIF_TX
  id: variable
  parameters:
    value: '50'
  states: {}
- name: GainRF_TX
  id: variable
  parameters:
    value: '100'
  states: {}
- name: LSB_NBFM_USB_CW
  id: variable
  parameters:
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1200000'
  states: {}
- name: analog_const_source_x_1
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_nbfm_tx_0_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: int(samp_rate/120)
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: int(samp_rate/30)
    tau: '75e-6'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '3500'
    low_cutoff_freq: '300'
    samp_rate: samp_rate/120
    type: fir_filter_fff
    width: '1200'
    win: firdes.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 1300+LSB_NBFM_USB_CW*1500
    low_cutoff_freq: '-1300+LSB_NBFM_USB_CW*1500'
    samp_rate: samp_rate/120
    type: fir_filter_ccc
    width: '200'
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: LSB_NBFM_USB_CW
    type: float
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: abs(LSB_NBFM_USB_CW)
    num_inputs: '3'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_selector_1
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '3'
    output_index: abs(LSB_NBFM_USB_CW)
    type: float
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '32767'
  states: {}
- name: blocks_udp_source_0
  id: blocks_udp_source
  parameters:
    eof: 'True'
    ipaddr: 127.0.0.1
    maxoutbuf: '2048'
    port: '9005'
    psize: '256'
    type: short
    vlen: '1'
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    maxoutbuf: '10'
    minoutbuf: '10'
    num_taps: '64'
    win: firdes.WIN_HAMMING
  states: {}
- name: iio_attr_sink_1
  id: iio_attr_sink
  parameters:
    attr_type: '0'
    channel: '"voltage0"'
    device: '"ad9361-phy"'
    output: 'True'
    required_enable: 'False'
    uri: '"ip:192.168.2.1"'
  states: {}
- name: iio_attr_sink_1_0
  id: iio_attr_sink
  parameters:
    attr_type: '0'
    channel: '"altvoltage1"'
    device: '"ad9361-phy"'
    output: 'True'
    required_enable: 'False'
    uri: '"ip:192.168.2.1"'
  states: {}
- name: iio_attr_updater_1
  id: iio_attr_updater
  parameters:
    attr: hardwaregain
    update_interval_ms: '1200'
    value: str(int(GainIF_TX - 50))
  states: {}
- name: iio_attr_updater_1_0
  id: iio_attr_updater
  parameters:
    attr: frequency
    update_interval_ms: '2500'
    value: str(int(Fr_TX))
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '0'
    auto_filter: 'True'
    bandwidth: '200000'
    buffer_size: '0x8000'
    cyclic: 'False'
    frequency: '145000000'
    samplerate: int(samp_rate)
    uri: 192.168.2.1
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '120'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '30'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1_1
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '120'
    taps: ''
    type: ccc
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: localhost
    port: '9004'
  states: {}

connections:
- [analog_const_source_x_1, '0', blocks_float_to_complex_0_0, '1']
- [analog_nbfm_tx_0_0, '0', rational_resampler_xxx_1_0, '0']
- [band_pass_filter_0, '0', analog_nbfm_tx_0_0, '0']
- [band_pass_filter_0_0, '0', rational_resampler_xxx_1, '0']
- [blocks_complex_to_float_0, '0', blocks_float_to_complex_0, '0']
- [blocks_complex_to_float_0, '1', blocks_multiply_const_vxx_0, '0']
- [blocks_float_to_complex_0, '0', band_pass_filter_0_0, '0']
- [blocks_float_to_complex_0_0, '0', rational_resampler_xxx_1_1, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_float_to_complex_0, '1']
- [blocks_selector_0, '0', iio_pluto_sink_0, '0']
- [blocks_selector_1, '0', band_pass_filter_0, '0']
- [blocks_selector_1, '1', hilbert_fc_0, '0']
- [blocks_selector_1, '2', blocks_float_to_complex_0_0, '0']
- [blocks_short_to_float_0, '0', blocks_selector_1, '0']
- [blocks_udp_source_0, '0', blocks_short_to_float_0, '0']
- [hilbert_fc_0, '0', blocks_complex_to_float_0, '0']
- [iio_attr_updater_1, out, iio_attr_sink_1, attr]
- [iio_attr_updater_1_0, out, iio_attr_sink_1_0, attr]
- [rational_resampler_xxx_1, '0', blocks_selector_0, '1']
- [rational_resampler_xxx_1_0, '0', blocks_selector_0, '0']
- [rational_resampler_xxx_1_1, '0', blocks_selector_0, '2']

metadata:
  file_format: 1
